* C:\Users\peter\OneDrive\Documents\LTspice\MOSbius_chip_library\MOSbius_chip_RO.asc
* Generated by LTspice 24.1.9 for Windows.
XX1 BUS01 BUS02 nMOS_currentMirror
XX4 BUS04 BUS05 BUS09 DP_nMOS_1x_A
XX5 BUS05 BUS06 BUS09 DP_nMOS_1x_B
XX2 BUS02 BUS03 CS_nMOS_4x_A
XX6 BUS06 BUS07 BUS09 BUS09 DP_nMOS_4x_A
XX7 BUS07 BUS08 BUS09 BUS09 DP_nMOS_4x_B
V1 VDD 0 {VDD}
XX9 BUS03 BUS02 CS_pMOS_4x_A
XX10 BUS04 BUS03 CS_pMOS_4x_B
XX11 BUS01 BUS02 pMOS_currentMirror
XX12 N001 NC_01 NC_02 NC_03 NC_04 NC_05 pMOS_currentMirror_array
XX3 BUS03 BUS04 CS_nMOS_4x_B
XX13 BUS07 BUS06 BUS10 BUS10 DP_pMOS_4x_A
XX14 BUS08 BUS07 BUS10 BUS10 DP_pMOS_4x_B
XX15 BUS06 BUS05 BUS10 DP_pMOS_1x_B
XX16 BUS05 BUS04 BUS10 DP_pMOS_1x_A
XX8 N003 NC_06 NC_07 NC_08 NC_09 NC_10 NC_11 nMOS_currentMirror_array
XX17 BUS08 BUS08 N002 inverter_A
XX18 N002 N002 BUS01 inverter_B
XX19 N003 NC_12 NC_13 NC_14 OTA_nMOS
XX20 N001 NC_15 NC_16 NC_17 OTA_pMOS
XX21 BUS10 chip_vdd
XX22 BUS09 chip_vss

* block symbol definitions
.subckt nMOS_currentMirror in out
X§M1 in in 0 0 NMOS_mobius m=1
X§M2 out in 0 0 NMOS_mobius m=1
.ends nMOS_currentMirror

.subckt DP_nMOS_1x_A gate drain source
X§M1 drain gate source 0 NMOS_mobius m=1
.ends DP_nMOS_1x_A

.subckt DP_nMOS_1x_B gate drain source
X§M1 drain gate source 0 NMOS_mobius m=1
.ends DP_nMOS_1x_B

.subckt CS_nMOS_4x_A gate drain
X§M1 drain gate 0 0 NMOS_mobius m=4
.ends CS_nMOS_4x_A

.subckt DP_nMOS_4x_A gate drain source substrate
X§M1 drain gate source substrate NMOS_mobius m=4
.ends DP_nMOS_4x_A

.subckt DP_nMOS_4x_B gate drain source substrate
X§M1 drain gate source substrate NMOS_mobius m=4
.ends DP_nMOS_4x_B

.subckt CS_pMOS_4x_A drain gate
X§M1 drain gate VDD VDD PMOS_mobius m=4
.ends CS_pMOS_4x_A

.subckt CS_pMOS_4x_B drain gate
X§M1 drain gate VDD VDD PMOS_mobius m=4
.ends CS_pMOS_4x_B

.subckt pMOS_currentMirror gate drain
X§M1 gate gate VDD VDD PMOS_mobius m=1
X§M2 drain gate VDD VDD PMOS_mobius m=1
.ends pMOS_currentMirror

.subckt pMOS_currentMirror_array in out1 out2 out4 out8 out16
X§M1 in in VDD VDD PMOS_mobius m=1
X§M2 out1 in VDD VDD PMOS_mobius m=1
X§M3 out2 in VDD VDD PMOS_mobius m=2
X§M4 out4 in VDD VDD PMOS_mobius m=4
X§M5 out8 in VDD VDD PMOS_mobius m=8
X§M6 out16 in VDD VDD PMOS_mobius m=16
.ends pMOS_currentMirror_array

.subckt CS_nMOS_4x_B gate drain
X§M1 drain gate 0 0 NMOS_mobius m=4
.ends CS_nMOS_4x_B

.subckt DP_pMOS_4x_A drain gate source nwell
X§M1 drain gate source nwell PMOS_mobius m=4
.ends DP_pMOS_4x_A

.subckt DP_pMOS_4x_B drain gate source nwell
X§M1 drain gate source nwell PMOS_mobius m=4
.ends DP_pMOS_4x_B

.subckt DP_pMOS_1x_B drain gate source
X§M1 drain gate source VDD PMOS_mobius m=1
.ends DP_pMOS_1x_B

.subckt DP_pMOS_1x_A drain gate source
X§M1 drain gate source VDD PMOS_mobius m=1
.ends DP_pMOS_1x_A

.subckt nMOS_currentMirror_array in out1 out2 out4 out8 out16 out32
X§M1 in in 0 0 NMOS_mobius m=1
X§M2 out1 in 0 0 NMOS_mobius m=1
X§M3 out2 in 0 0 NMOS_mobius m=2
X§M4 out4 in 0 0 NMOS_mobius m=4
X§M5 out8 in 0 0 NMOS_mobius m=8
X§M6 out16 in 0 0 NMOS_mobius m=16
X§M7 out32 in 0 0 NMOS_mobius m=32
.ends nMOS_currentMirror_array

.subckt inverter_A inn inp out
X§M1 out inn 0 0 NMOS_mobius m=16
X§M2 out inp VDD VDD PMOS_mobius m=16
.ends inverter_A

.subckt inverter_B inn inp out
X§M1 out inn 0 0 NMOS_mobius m=16
X§M2 out inp VDD VDD PMOS_mobius m=16
.ends inverter_B

.subckt OTA_nMOS biasn inp inn out
X§M1 co_so biasn 0 0 NMOS_mobius m=2
X§M2 out_b inp co_so 0 NMOS_mobius m=1
X§M3 out inn co_so 0 NMOS_mobius m=1
X§M4 out out_b VDD VDD PMOS_mobius m=1
X§M5 out_b out_b VDD VDD PMOS_mobius m=1
.ends OTA_nMOS

.subckt OTA_pMOS biasp inp inn out
X§M1 co_so biasp VDD VDD PMOS_mobius m=2
X§M2 out_b inp co_so VDD PMOS_mobius m=1
X§M3 out inn co_so VDD PMOS_mobius m=1
X§M4 out_b out_b 0 0 NMOS_mobius m=1
X§M5 out out_b 0 0 NMOS_mobius m=1
.ends OTA_pMOS

.subckt chip_vdd chip_vdd
R1 chip_vdd VDD .000001
.ends chip_vdd

.subckt chip_vss chip_vss
R1 chip_vss 0 0.000001
.ends chip_vss

.global VDD
.param VDD = 2.5
.inc transistor_models_tsmc025_public.inc
.ic v(bus01)=2.5
* Common Source
* Differential Pairs\n1x
* Differential Pairs\n4x
* Current Mirror\n1 : 1
* Current Mirror Array
* Inverters\n16x
* .op
* Note: Do not connect a BUS directly to VDD or VSS even with a jumper. \nUse the Chip_VDD and Chip_VSS.
* Note: The numbers on the symbols correspond to the PCB pin numbers.
* Pull your pMOS bias current from this node
* Push your nMOS bias current into this node
.tran 1u
.backanno
.end
